v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {lab_wire.sym} -70 40 2 1 {name=p1 sig_type=std_logic lab=NSUP}
C {ipin.sym} -230 -180 0 0 {name=p3 lab=PSUP}
C {ipin.sym} -230 -160 0 0 {name=p4 lab=NSUP}
C {lab_wire.sym} -230 -160 0 1 {name=p5 sig_type=std_logic lab=NSUP}
C {lab_wire.sym} -230 -180 0 1 {name=p6 sig_type=std_logic lab=PSUP}
C {ipin.sym} -110 -20 0 0 {name=p7 lab=A}
C {ipin.sym} -110 20 0 0 {name=p8 lab=B}
C {opin.sym} 100 0 0 0 {name=p12 lab=Y}
C {blocks/nand_2/nand_2.sym} -60 0 0 0 {name=x1}
C {blocks/not/not.sym} 50 0 0 0 {name=x2}
C {lab_wire.sym} 40 40 2 1 {name=p9 sig_type=std_logic lab=NSUP}
C {lab_wire.sym} -50 -40 0 1 {name=p10 sig_type=std_logic lab=PSUP}
C {lab_wire.sym} 60 -40 0 1 {name=p11 sig_type=std_logic lab=PSUP}
