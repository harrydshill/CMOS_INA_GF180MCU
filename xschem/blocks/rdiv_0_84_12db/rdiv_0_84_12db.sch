v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {iopin.sym} 30 -230 0 0 {name=p1 lab=IN+}
C {iopin.sym} 30 50 0 0 {name=p2 lab=IN-}
C {iopin.sym} 30 -70 0 0 {name=p3 lab=OUT-}
C {iopin.sym} 30 -130 0 0 {name=p4 lab=OUT+}
C {ipin.sym} -130 -180 0 0 {name=p5 lab=PSUP}
C {ipin.sym} -130 -140 0 0 {name=p6 lab=PSUP_LV}
C {ipin.sym} -130 -110 0 0 {name=p7 lab=NSUP}
C {ipin.sym} -140 -70 0 0 {name=p8 lab=CONF0}
C {ipin.sym} -140 -40 0 0 {name=p9 lab=CONF1}
C {ipin.sym} -140 -10 0 0 {name=p10 lab=CONF2}
